Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-04-12T15:38:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160720_1515(x64) - Exporter 17.0.501.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 12 15:38:46 2018 * Host: B3ROBRAWR3853 * Database: C:\Users\LC\AppData\Local\Temp\{86163F9B-9713-4DD2-A3FE-239D6774B608}\ifc * Database version: 5507 * Database creation date: Thu Apr 12 15:38:44 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu Apr 12 15:38:44 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 12 15:38:44 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcDistributionControlElement: RC-A4.2, E_Controller_Room_MEPcontent_ABB_RC A4 2_INT-EN:RC-A4.2:1361550
In: V00
Type - Material: Color RGB 255-000-000, Color RGB 084-090-090, Color RGB 197-199-196
Type - Dimensions - Depth: 277 mm; Height: 202 mm; Rotation U-Axis Correction: 270 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 180 deg; Width: 50 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC
Type - Identity Data - Article Description: RC/A4.2 Room Controller Basis Device 4F; Article Type: RC/A4.2; Category: EL_BUSSYSTEM_ACTOR; Content Supplier URL: www.mepcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: RC/A4.2 Room Controller Basis Device 4F; EMCS Version: 3.0; ETIM Article Class: EC001581; Family Version: 11.14; GTIN: 4016779676472; Manufacturer: ABB; Manufacturer Art. No.: 2CDG110104R0011; Manufacturer URL: https://new.abb.com/products/2CDG110104R0011; MEPcontent Class: CONTROLLER_ROOM; Model: RC/A4.2; OmniClass Number: 23.80.00.00; OmniClass Title: Electric Power and Lighting; Product Line: KNX - Multifunction Room Automation - Room Controller Series; Revit Version: 2016; Type Name: RC-A4.2; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Communication Devices; 04: yes; 06: no; BE/M4.12.1: BE-M4.12.1: BE-M4.12.1; BE/M4.230.1: BE-M4.230.1: BE-M4.230.1; BE/M4.24.1: BE-M4.24.1: BE-M4.24.1; ES/M2.230.1: ES-M2.230.1: ES-M2.230.1; ES/M2.24.1: ES-M2.24.1: ES-M2.24.1; Family Name: E_Controller_Room_MEPcontent_ABB_RC A4 2_INT-EN; JA/M2.230.1: JA-M2.230.1: JA-M2.230.1; JA/M2.24.1: JA-M2.24.1: JA-M2.24.1; LR/M1.6.2: LR-M1.6.2: LR-M1.6.2; SA/M2.16.1: SA-M2.16.1: SA-M2.16.1; SA/M2.6.1: SA-M2.6.1: SA-M2.6.1; SD/M2.6.2: SD-M2.6.2: SD-M2.6.2; UD/M1.300.1: UD-M1.300.1: UD-M1.300.1
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; M1: BE-M4.12.1: BE-M4.12.1; M2: LR-M1.6.2: LR-M1.6.2; M3: SA-M2.16.1: SA-M2.16.1; M4: SA-M2.6.1: SA-M2.6.1; Offset: 0 mm
Dimensions - Area: 0.252857 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.00284706 m3
Identity Data - Design Option: Main Model; Function Code: E6222BS; Mark: 2
Other - BE/M4.12.1 Visibility: yes; BE/M4.230.1 Visibility: no; BE/M4.24.1 Visibility: yes; ES/M2.230.1 Visibility: no; ES/M2.24.1 Visibility: no; Family: E_Controller_Room_MEPcontent_ABB_RC A4 2_INT-EN: RC-A4.2; Family and Type: E_Controller_Room_MEPcontent_ABB_RC A4 2_INT-EN: RC-A4.2; JA/M2.230.1 Visibility: no; JA/M2.24.1 Visibility: no; LR/M1.6.2 Visibiity: yes; SA/M2.16.1 Visibility: yes; SA/M2.6.1 Visibility: yes; SD/M2.6.2 Visibility: no; Type: E_Controller_Room_MEPcontent_ABB_RC A4 2_INT-EN: RC-A4.2; Type Id: E_Controller_Room_MEPcontent_ABB_RC A4 2_INT-EN: RC-A4.2; UD/M1.300.1 Visibility: no
Phasing - Phase Created: 3. Nieuwbouw
